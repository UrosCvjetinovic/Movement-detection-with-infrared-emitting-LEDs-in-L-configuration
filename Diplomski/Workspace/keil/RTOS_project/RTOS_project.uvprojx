# Keil uVision project RTOS_project.uvprojx, settings and files
target TM4C123GH6PM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ./Drivers; ./Sources
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers
    ./Drivers/driverlib/: gpio.c i2c.c interrupt.c sysctl.c systick.c timer.c uart.c usb.c cpu.c
    ./Drivers/utils/: uartstdio.c
  group Sources
    ./Sources/: Application.h main.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 1.0.1
