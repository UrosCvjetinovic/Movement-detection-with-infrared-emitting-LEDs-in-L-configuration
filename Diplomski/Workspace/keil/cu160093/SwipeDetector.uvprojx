# Keil uVision project SwipeDetector.uvprojx, settings and files
target TM4C123GH6PM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SwipeDetector +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ./Drivers/; ./Source/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./Source/: main.c Application.h Application.c Common.h Communication.c Communication.h ConfigureHardware.c ConfigureHardware.h Priorities.h ProximityClickApi.c ProximityClickApi.h UserFeedback.c UserFeedback.h GestureAlgorithm.c GestureAlgorithm.h ReadThread.c ReadThread.h si115xRegisters.h
  group Drivers
    ./Drivers/utils/: uartstdio.c
    ./Drivers/inc/: hw_gpio.h hw_i2c.h hw_memmap.h hw_uart.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h hw_ints.h
    ./Drivers/driverlib/: gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h pin_map.h uart.c uart.h usb.c usb.h sysctl.c sysctl.h systick.c systick.h cpu.h cpu.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 1.0.1
