# Keil uVision project Test.uvprojx, settings and files
target TM4C123GH6PM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ./Drivers.; ./Source/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./Source/: main.c Application.h
  group Drivers
    ./Drivers/driverlib/: cpu.c gpio.c interrupt.c sysctl.c systick.c uart.c
    ./Drivers/utils/: uartstdio.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
